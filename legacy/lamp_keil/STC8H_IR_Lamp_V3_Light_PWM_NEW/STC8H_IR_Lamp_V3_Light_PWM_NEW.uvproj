# Keil uVision project STC8H_IR_Lamp_V3_Light_PWM_NEW.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: STC8H_IR_Lamp_V3_Light_PWM_NEW +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\_libs
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c
  group lib
    ./_libs/: Config.h STC8H.h Type_def.h STC8H_PWM.h STC8G_H_Switch.h STC8G_H_NVIC.c STC8G_H_NVIC.h STC8H_PWM.c STC8H_PWM_Isr.c
