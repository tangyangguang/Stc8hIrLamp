# Keil uVision project STC8H_IR_Lamp_V3_Controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: STC8H_IR_Lamp_V3_Controller +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\_libs
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c
  group lib
    ./_libs/: STC8H.h Type_def.h
